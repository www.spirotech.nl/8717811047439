Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Cool Vessel_EMCC-G 125_INT-EN.ifc
Time: 2025-08-05T18:19:13+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Cool Vessel_INT-EN:EMCC-G 125, HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Cool Vessel_INT-EN:EMCC-G 125:1763105
In: F00
Type - Material: Color RGB 200-200-200, Color RGB 200-000-000, Color RGB 040-040-040, Color RGB 173-196-207, Color RGB 168-128-048
Type - Other - Category: Mechanical Equipment; Boiler Type 500: no; Bottom Plate: 264 mm; Drain Distance: 392 mm; Drain Height: 479 mm; EMCC-G(Z) 125-200 Feet: yes; EMCC-G(Z) 300-500 Feet: no; EMCC-G 125 Boiler: yes; EMCC-G 200 Boiler: no; EMCC-G 300 Boiler: no; EMCC-G 500 Boiler: no; Family Name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Cool Vessel_INT-EN; Pipe Height: 422.9 mm; Pipe Length: 47 mm; Plate Distance: 290.2 mm; Top Geometry: 162 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 19.05 mm; Diameter: 500 mm; Drain Diameter: 50 mm; Height: 1167 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Primary Expansion vessels MultiControl Cool 125 ltr; Article Type: EMCC-G 125; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Primary Expansion vessels MultiControl Cool 125 ltr; EMCS Version: 5.0; ETIM Article Class: EC010958; Family Version: 12.24; GLN: 8717811000007; GTIN: 8717811047439; Manufacturer: Spirotech; Manufacturer Art. No.: EMCC-G 125; Manufacturer URL: https://www.spirotech.com/8717811047439; MEPcontent Class: EXPANSIONVESSEL; Model: EMCC-G 125; OmniClass Number: 23.75.70.11.14; OmniClass Title: Expansion Vessels; Product Line: Spirotech; Revit Version: 2023; Type Name: EMCC-G 125; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Grey: Color RGB 200-200-200
Type - Mechanical - Max. Medium Temperature (continuous): 0 C; Pre-pressure: 0; Volume: 0.125 m3
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EMCC-G 125; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EMCC-G 125
Other - Family: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Cool Vessel_INT-EN; Family and Type: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Cool Vessel_INT-EN: EMCC-G 125; Type: EMCC-G 125; Type Id: 1763076
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 5.7744 m2; Volume: 0.159604 m3
Identity Data - Mark: 4
Mechanical - Drain Fixture Units: 0; Flow 1: 0 m3/s; Flow 2: 0 m3/s; Flow 3: 0 m3/s; System Classification: Undefined,Sanitary,Undefined
Phasing - Phase Created: 3. New Construction

# IfcDistributionPort (4)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
InPort_1763105_2 | SINK
OutPort_1763105_4 | SOURCE | SystemType: SEWAGE
OutPort_1763105_5 | SOURCE
OutPort_1763105_6 | SOURCE
